Commit message: Add files via upload

File: objects/decor/banc/banc.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision mesh filename=Barriere.obj scale=0.01 0.01 0.01; visual mesh filename=Barriere.obj scale=0.01 0.01 0.01
